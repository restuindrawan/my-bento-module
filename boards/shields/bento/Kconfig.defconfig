## boards/shields/bento/Kconfig.defconfig
```kconfig
if SHIELD_BENTO

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "bento"

endif
```
